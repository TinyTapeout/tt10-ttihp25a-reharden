v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/xnor2_1.sym} 450 -320 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {ipin.sym} 60 -330 0 0 {name=p1 lab=AA

}
C {ipin.sym} 60 -300 0 0 {name=p2 lab=BB}
C {opin.sym} 50 -270 0 0 {name=p3 lab=YY
}
C {lab_pin.sym} 390 -340 0 0 {name=p4 sig_type=std_logic lab=AA}
C {lab_pin.sym} 390 -300 0 0 {name=p5 sig_type=std_logic lab=BB}
C {lab_pin.sym} 510 -320 2 0 {name=p6 sig_type=std_logic lab=YY}
